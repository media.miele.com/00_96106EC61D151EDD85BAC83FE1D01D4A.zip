Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-04T13:12:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 04 13:12:45 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\73f7099e-db9a-4115-acd4-ad45e5e99293\a46e2b3e-710e-48fe-bcc2-6c1683aef9b3\ifc * Database version: 5507 * Database creation date: Thu Aug 04 13:12:44 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 04 13:12:44 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 04 13:12:44 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11926690_EU_PWM909ELDPDD_LW:51909015_EU_11926690_PWM909ELDPDD_LW, (2)
In: Default
Type - Material: z_Miele_Design_Stainless_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 51909015_EU_11926690_PWM909ELDPDD_LW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 51909015_EU_11926690_PWM909ELDPDD_LW
Material: z_Miele_Design_Stainless_Steel, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Powder Coat_Lotus White, Default, z_Miele_Connection_Water_OUT, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_IN, z_Miele_Connection_Network, z_Miele_Connection_Electric, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
